# Keil uVision project lab2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RB2 Microchip
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0 - 0xFF) CLOCK(60000000) MODP2
  output: lab2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 lab.c
